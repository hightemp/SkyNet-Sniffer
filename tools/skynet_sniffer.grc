<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>skynet_sniffer</value></param>
<param><key>title</key><value>SkyNet Sniffer</value></param>
<param><key>author</key><value>Fabian Haerer</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_shift</value></param>
<param><key>value</key><value>150e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>12.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>868.0377e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>samp_rate_after_FIR_filter/50000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trans</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_after_FIR_filter</value></param>
<param><key>value</key><value>samp_rate/dec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>"new.pcap"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename_0</value></param>
<param><key>value</key><value>"old.pcap"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>20000</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_1</value></param>
<param><key>low</key><value>0.00001</value></param>
<param><key>high</key><value>0.00002</value></param>
<param><key>init</key><value>0</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>frequency-freq_shift</value></param>
<param><key>corr0</key><value>30.5</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>30</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate_after_FIR_filter, cutoff*1e3, trans*100, firdes.WIN_BLACKMAN, 6.76)</value></param>
<param><key>center_freq</key><value>freq_shift</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1</value></param>
<param><key>gain</key><value>2</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>bachelor_skynet_extended_analyze</key>
<param><key>id</key><value>bachelor_skynet_extended_analyze_0</value></param>
</block>
<block>
<key>bachelor_skynet_wireshark_sink</key>
<param><key>id</key><value>bachelor_skynet_wireshark_sink_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_1</value></param>
<param><key>file</key><value>filename</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>bachelor_skynet_analyze</key>
<param><key>id</key><value>bachelor_skynet_analyze_0</value></param>
<param><key>samp_rate</key><value>int(samp_rate_after_FIR_filter)</value></param>
<param><key>sampels_per_symbol</key><value>samp_per_sym</value></param>
<param><key>threshold</key><value>3</value></param>
</block>
<block>
<key>bachelor_skynet_wireshark_sink</key>
<param><key>id</key><value>bachelor_skynet_wireshark_sink_0_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_1_0</value></param>
<param><key>file</key><value>filename_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<connection><source_block_id>bachelor_skynet_wireshark_sink_0</source_block_id><sink_block_id>blocks_file_sink_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>bachelor_skynet_analyze_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bachelor_skynet_wireshark_sink_0_0</source_block_id><sink_block_id>blocks_file_sink_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bachelor_skynet_analyze_0</source_block_id><sink_block_id>bachelor_skynet_wireshark_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>bachelor_skynet_extended_analyze_0</source_block_id><sink_block_id>bachelor_skynet_wireshark_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>bachelor_skynet_extended_analyze_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>blocks_threshold_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_1</source_block_id><sink_block_id>bachelor_skynet_analyze_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_1</source_block_id><sink_block_id>bachelor_skynet_extended_analyze_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>bachelor_skynet_analyze_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>bachelor_skynet_extended_analyze_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
